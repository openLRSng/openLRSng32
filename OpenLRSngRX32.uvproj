# Keil uVision project OpenLRSngRX32.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: aadamson +hex
  c flags: Optim=4 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\src;.\Libraries\CMSIS\Device\ST\STM32F10x\Include;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\src\drv;.\src\sensors
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./src/: binding.c hw_defines.c main.c printf.c
  group Drv
    ./src/drv/: drv_adc.c drv_gpio.c drv_i2c.c drv_pwm.c drv_rfm.c drv_spi.c drv_system.c drv_uart.c
    ./src/sensors/: drv_mpu6050.c
  group Lib
    ./src/: stm32f10x_it.c system_stm32f10x.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./src/startup/: startup_stm32f10x_md.s
